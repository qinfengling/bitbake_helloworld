addtask compile
addtask build
addtask clean
addtask install
